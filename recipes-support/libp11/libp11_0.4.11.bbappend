
SRC_URI = "https://github.com/OpenSC/libp11-0.4.11.tar.gz"
SRC_URI[sha256sum] = "d6197ff909cff36bb047705ef393f63d90b1323a8e3c9e7021faa693db109f93"
