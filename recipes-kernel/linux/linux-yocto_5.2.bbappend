require linux-yocto-nxp-s32g2xx.inc

KBRANCH_nxp-s32g2xx  = "v5.2/standard/nxp-s32g2xx"

LINUX_VERSION_nxp-s32g2xx ?= "5.2.x"
