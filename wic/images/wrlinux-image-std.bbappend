include wrlinux-image-nxp-s32g2xx.inc
